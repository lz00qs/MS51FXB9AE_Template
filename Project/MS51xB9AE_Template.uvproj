# Keil uVision project MS51xB9AE_Template.uvproj, settings and files
target MS51xB9AE_Template (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: MS51xB9AE_Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib\Device\Include;..\StdDriver\inc;..\UsrDriver\inc;..\User\inc
  group Startup
    ../FWLib/Startup/Keil/: STARTUP.A51
  group User
    ../User/src/: main.c
  group StdDriver
    ../StdDriver/src/: uart.c delay.c sys.c
